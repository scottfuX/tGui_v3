# Keil uVision project stm32f4Demo.uvprojx, settings and files
target STM32F429IGT6Demo (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F429IGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.5.0
  cpu: IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f4Demo +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F429_439xx,
  c include: ..\Libraries\CMSIS\Device\ST\STM32F4xx\Include;..\Libraries\CMSIS\Include;..\Libraries\STM32F4xx_StdPeriph_Driver\inc;..\User;..\User\SDRAM;..\FreeRTOS;..\FreeRTOS\include;..\FreeRTOS\portable\MemMang;..\FreeRTOS\portable\RVDS\ARM_CM4F;..\FreeRTOS\portable\Keil;..\FreeRTOS\portable;..\TGui;..\TGui\libraries
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\stm32f4Demo.sct
  group STARTUP
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f429_439xx.s
  group CMSIS
    ../Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group STM32F4xx_StdPeriph_Driver
    ../Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group User
    ../User/: stm32f4xx_it.c main.cpp
    ../User/delay/: delay_conf.c
    ../User/flash/: flash_conf.c
    ../User/lcd/: lcd_conf.c
    ../User/led/: led_conf.c
    ../User/sdram/: sdram_conf.c
    ../User/usart/: usart_conf.c
    ../User/tim/: tim_conf.c
    ../User/sdio/: sdio_sd_conf.c
  group Test
    ../User/test/: sdramtest.c
  group Fatfs
    ../User/fatfs/: diskio.c ff.c
    ../User/fatfs/option/: unicode.c
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS_portable
    ../FreeRTOS/portable/RVDS/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group Touch
    ../User/touch/: gt9xx.c touch_i2c.c
  group TGui
    ../TGui/TContainter/: TArray.cpp TConnectList.cpp TFuncList.cpp TString.cpp
    ../TGui/interface_conf/: tgui_conf.c
    ../TGui/: TGuiMain.cpp
    ../TGui/TWidget/: TAbstractButton.cpp TAbstractSlider.cpp TCheckBox.cpp TDialog.cpp TFrame.cpp TLabel.cpp TPushButton.cpp TRadioButton.cpp TSlider.cpp TWidget.cpp TImageBox.cpp TSwitch.cpp TWindow.cpp TIconButton.cpp
    ../TGui/TObject/: TConnection.cpp TObject.cpp TRect.cpp TSize.cpp TDirver.cpp TEven.cpp TApplication.cpp TBuffer.cpp TImage.cpp TFont.cpp
    ../TGui/TPainter/: TBufPainter.cpp
  group picture_lib
    ../TGui/libraries/picture_lib/: bmp.c gif.c piclib.c tjpgd.c lodepng.cpp
  group exfuns_lib
    ../TGui/libraries/exfuns_lib/: exfuns.c aux_data.c
  group demo
    ../TGui/demo/: Desktop.cpp User.cpp UserPhoto.cpp
